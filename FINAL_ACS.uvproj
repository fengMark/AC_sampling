# Keil uVision project FINAL_ACS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: FINAL_ACS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ACS_main.c Solve.h Solve.c M12864.c M12864.h ZK.c ZK.h
